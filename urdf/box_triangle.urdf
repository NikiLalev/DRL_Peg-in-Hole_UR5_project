Commit message: triangle shape added

File: urdf/box_triangle.urdf (robot description, URDF)
Before this commit: robot hole_box, 1 links, 0 joints
Links:
- link hole_box_link: geometry collision mesh filename=/urdf/triangle.stl scale=1 1 1; visual mesh filename=/urdf/triangle.stl scale=1 1 1
